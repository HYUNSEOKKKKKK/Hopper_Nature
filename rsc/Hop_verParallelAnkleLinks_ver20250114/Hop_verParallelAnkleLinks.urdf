Commit message: 2.2 th -> only change toe

File: rsc/Hop_verParallelAnkleLinks_ver20250114/Hop_verParallelAnkleLinks.urdf (robot description, URDF)
Before this commit: robot DHAL, 11 links, 10 joints
Links:
- link Foot: geometry collision box size=0.06 0.1 0.03; collision box size=0.20 0.1 0.03
